options:
  parameters:
    generate_options: qt_gui
    id: Test
    output_language: python
    title: Test
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: '1420000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: w
  id: variable
  parameters:
    value: window.blackmanharris(N)
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/tyang/Projects/data/strw-ra-scripts/session_03_data_raw
    type: complex
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/tyang/Projects/data/strw-ra-scripts/session_03_data_fft
    type: complex
    vlen: N
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: /home/tyang/Projects/strw-ra-scripts/data/session_03_data_fft_int
    type: float
    vlen: N
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: 4*N
    type: float
    vlen: N
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[1/N,]*N'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf,bias=1"'
    bb_gain0: '32'
    freq0: frequency
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '32'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_file_sink_1_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [fft_vxx_0, '0', blocks_file_sink_1, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
